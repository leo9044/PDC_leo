# Enable IC_app auto-start for dual-display setup
# IC_app runs on DSI display (card0, DSI-1)
# HU_MainApp_Compositor runs on HDMI display (card1, HDMI-A-1)

SYSTEMD_AUTO_ENABLE = "enable"
